<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\f407_motor_driver.ewp</path>
    </project>
    <batchBuild />
</workspace>
