# IAR project f407_motor_driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32F4; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\; ..\project; ..\project\modules; ..\project\modules\stm32; ..\project\modules\stm32\uart; ..\project\modules\stm32\led; ..\project\mdl_config; ..\project\application; ..\project\ST; ..\project\ST\core; ..\project\ST\ll
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../project/: main.c
  group application
    ../project/application/: app_uart.c app_uart.h system_init.c system_init.h
  group config
    ../project/mdl_config/: led_config.h uart_config.h
  group modules/stm32/led
    ../project/modules/stm32/led/: led_hw.c led_hw.h
  group modules/stm32/uart
    ../project/modules/stm32/uart/: uart.c uart.h uart_hw.c uart_hw.h
  group ST/CMSIS
    ../project/ST/core/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h core_cm7.h mpu_armv7.h mpu_armv8.h startup_stm32f407xx.s stm32f407xx.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group ST/LL
    ../project/ST/ll/: stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.c stm32f4xx_ll_crc.h stm32f4xx_ll_dma.c stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.c stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.c stm32f4xx_ll_exti.h stm32f4xx_ll_gpio.c stm32f4xx_ll_gpio.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_pwr.c stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.c stm32f4xx_ll_rcc.h stm32f4xx_ll_rtc.c stm32f4xx_ll_rtc.h stm32f4xx_ll_spi.c stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.c stm32f4xx_ll_tim.h stm32f4xx_ll_usart.c stm32f4xx_ll_usart.h stm32f4xx_ll_utils.c stm32f4xx_ll_utils.h
